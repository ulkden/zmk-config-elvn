## boards/shields/elvn/Kconfig.defconfig
```kconfig
if SHIELD_ELVN

config ZMK_KEYBOARD_NAME
    default "elvn"

endif # SHIELD_ELVN
```
